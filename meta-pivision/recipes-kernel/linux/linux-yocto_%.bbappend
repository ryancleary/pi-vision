FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://quiet-display.cfg"

